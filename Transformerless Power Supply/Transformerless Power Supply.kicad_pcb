# Repository nityas24/Transformerless-Power-Supply---KiCAD

File README.md:

This project involves designing a simple transformerless power supply using KiCAD. The circuit takes standard AC mains input (e.g., 120V/230V) and provides a low-voltage DC output suitable for powering small electronic circuits.

Instead of a bulky transformer, the design uses a capacitive dropper circuit consisting of:

- Capacitor (X-rated safety capacitor) – reduces the AC voltage.

- Resistors – limit inrush current and discharge the capacitor.

- Diodes – form a bridge rectifier to convert AC to DC.

- Zener diode or regulator – stabilizes the output voltage.

- Filter capacitor – smooths out the DC signal.

## KiCad design Transformerless Power Supply/Transformerless Power Supply.kicad_pcb

Parts:
C1: 0.1uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C2: 1000uF; CP_Radial_D10.0mm_P5.00mm
C3: 470uF; CP_Radial_D10.0mm_P3.80mm
C4: 225K/2.2uF; C_Rect_L18.0mm_W6.0mm_P15.00mm_FKS3_FKP3
D1, D2, D3, D4: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D5, D6: D_Zener; D_A-405_P7.62mm_Horizontal
D7: LED; LED_D5.0mm
J1, J2: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
R1, R2: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R4: 2.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: LM7805_TO220; TO-220-3_Vertical

Connections:
/5V: C3.1, J2.1, U1.3 (VO)
GND: C1.2, C2.2, C3.2, D3.2 (A), D4.2 (A), D7.1 (K), J2.2, R1.2, R2.2, U1.2 (GND)
unnamed: C4.2, D1.2 (A), D3.1 (K), R3.2
unnamed: C1.1, C2.1, D1.1 (K), D2.1 (K), D5.1 (K), D6.1 (K), R4.1, U1.1 (VI)
unnamed: D2.2 (A), D4.1 (K), J1.1
unnamed: D5.2 (A), R1.1
unnamed: D6.2 (A), R2.1
unnamed: D7.2 (A), R4.2
unnamed: C4.1, J1.2, R3.1

Board: 2 copper layers, 52.0 x 41.5 mm, 18 parts (0 on the bottom side), 9 nets.
